
require recipes-kernel/linux/common.inc
