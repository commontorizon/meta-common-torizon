# Add regexp command to GRUB
GRUB_BUILDIN += "regexp"
